# Keil uVision project Lab6.uvprojx, settings and files
target Lab6 (6140000::V6.14::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab6
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s Lab6grader.c Sound.c Key.c Lab6.c Song.c
    ../inc/: wave.c DAC.c Timer3A.c
  group Object code
    ./: uart.o pll.o
software components: CMSIS:CORE 5.6.0
